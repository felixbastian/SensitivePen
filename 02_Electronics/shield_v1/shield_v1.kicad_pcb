# Repository felixbastian/SensitivePen

File README.md:

# SensitivePen
Fork of main project to implement:
- data preparation of sensor data
- Feature Engineering
- ML pipeline development

## KiCad design 02_Electronics/shield_v1/shield_v1.kicad_pcb

Parts:
C1, C2, C3, C4: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1, J2, J3: Conn_01x02_Male; PinHeader_1x02_P1.00mm_Horizontal
J4, J5: DF12_3.0_-36DP-0.5V_86_; DF123036DP05V86; Mouser Part Number 798-DF123036DP0.5V86
J6: FH12-10S-0.5SH(55); FH12-10S-0.5SH(55)_HIR; MANUFACTURER_PART_NUMBER FH12-10S-0.5SH(55)
R1: 330 Ohm; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: FT5316DME; QFN40P600X600X60-49N

Connections:
+3V3: C3.2, J2.2, J3.2, J4.30, J4.32, J5.29, J5.31, R1.1, U1.24 (VDD3)
A1: J2.1, J4.4, J5.3
GND: C1.1, C2.1, C3.1, C4.1, J3.1, J4.34, J4.36, J5.33, J5.35, U1.1 (VSSA), U1.25 (VSS), U1.26 (VSSD)
unnamed: C4.2, U1.23 (VDD5)
RX1: J6.3, U1.37 (RX1)
RX2: J6.4, U1.38 (RX2)
RX3: J6.5, U1.39 (RX3)
RX4: J6.6, U1.40 (RX4)
RX5: J6.7, U1.41 (RX5)
RX6: J6.8, U1.42 (RX6)
SCL: J1.1, J4.28, J5.27, U1.34 (SCL/SSEL)
SDA: J1.2, J4.26, J5.25, U1.33 (SDA/SCL)
TX1: J6.1, U1.2 (TX1)
TX2: J6.2, U1.3 (TX2)
TX3: J6.9, U1.4 (TX3)
TX4: J6.10, U1.5 (TX4)
VDDA: C1.2, R1.2, U1.36 (VDDA)
VDDD: C2.2, U1.27 (VDDD)

Notes on the sheet:
TOP
BOTTOM

Board: 2 copper layers, 33.0 x 33.0 mm, 12 parts (1 on the bottom side), 18 nets.

## KiCad design 02_Electronics/MovuinoShieldPressure/MovuinoShieldPressure.kicad_pcb

Board: 2 copper layers, 10.5 x 33.0 mm, 4 parts (2 on the bottom side), 3 nets.

Parts:
J1: DF12-36NOLEGS-FEMALE; DF12-36-DP-NL-noPad
J2: Rext; PinHeader_1x02_P2.54mm_Vertical
J3: DF12-36NOLEGS-MALE; DF12-36-DP-NL
Rref: 330 Ohm; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
/ADC: J1.2, J2.2, J3.1, Rref.1
GND: J1.33, J1.35, J3.34, J3.36, Rref.2
VCC: J1.31, J2.1, J3.32

## KiCad design 02_Electronics/MovuinoESP8266/V0.99.3-ESP12-3-mech/V0.99.3-ESP12-3-mech.kicad_pcb

Parts:
C1_1-0: DNP; 0402-CAP
C1_2-0, C2_1-0, C2_2-0, C4_1-0: 10uF; 0402-CAP
C2_3-0, C3_2-0: 1uF; 0402-CAP
C3_1-0: 470nF; 0402-CAP
C6_1-0, C6_2-0, C7_1-0, C8_1-0: 0.1uF; 0402-CAP
C6_3-0: 0.01uF; 0402-CAP
D2_1-0: MBR120; SOD-123
J2-T-0: DF12-36NOLEGS-FEMALE; DF12-36-DP-NL
J4-B-0: DF12-36NOLEGS-MALE; DF12-36-DP-NL
JP1: JUMPER-31-2-CLOSED; 0402-JUMPER3-1-2-CLOSED
LED1-0: WS2812B3535; LED3535
LED4_1-0: Power; LED-0603-LCSC90692
PWR1-0: PWR2P_1.0
Q1-0, Q2-0: TRANS_NPNMMBT2222AWT; SOT-323
Q5-0: AO3401; SOT23-R
R2_1-0, R2_2-0: 100KR; R0402-SMALL-TDOCU
R3_2-0, R3_3-0, R3_10, R5_2-0, R5_6-0, R5_7-0, R5_8-0, R6_1-0, R6_2-0: 10KR; R0402-SMALL-TDOCU
R4-1-0: 4.87KR; R0402-SMALL-TDOCU
R4_2-0: 120R; R0402-SMALL-TDOCU
R5_1-0: 33KR; R0402-SMALL-TDOCU
R5_3-0: 1KR; 0402-RES
R5_4-0, R5_5-0: 10KR; 0402-RES
R5_9-0: 4.7KR; R0402-SMALL-TDOCU
R8_1-0: 470R; R0402-SMALL-TDOCU
S2: SMD-SWITCH-4P3.53-SMD; LCSC145875-3.5*3
TP1, TP2: TESTPOINT1X1.5MM_NOCREAM_NOSILK; PAD-1X1.5_NOSILK
U1-0: CP2104; QFN24_4MM_SMSC
U2-0: AP2112-3.3; SOT23-5
U3-0: STM6601; TDFN12
U4-0: MCP73831; SOT23-5
U5-0: ESP-12F-ALT; ESP-12-ALT
U6-0: MPU-9250; LEAD-QFN24-MPU9250
U7-0: BME280
U$4, U$7, U$9, U$11, U$12, U$13: 0402-JUMPERCLOSED-DEFAULT; 0402-JUMPER-CLOSED
U$8: LOGO_MOVUINOBOTTOM_11MM; LOGO_MOVUINO_BMP_11MM-BOTTOM
U$15: LOGO-CRI-NEW-110MM-BOTTOM-SILK; LOGO_CRI-NEW-BMP10MM-BOTTOM
USB1: MICRO-USB-SMD(ZX62-B-5PA)JING-LCSC10418; MICRO-USB5+6P-SMD-0.65-AB-TB-LCSC10418

Connections:
3.3V: C1_2-0.1, C2_2-0.1, C2_3-0.1, C6_1-0.1, C6_3-0.1, C7_1-0.1, C8_1-0.1, J2-T-0.6, J2-T-0.8, J4-B-0.30, J4-B-0.32, JP1.1, LED1-0.2 (VDD), R3_2-0.2, R3_3-0.2, R3_10.2, R5_6-0.1, R5_7-0.2, R5_8-0.2, R6_1-0.2, R6_2-0.2, U1-0.5 (VIO), U1-0.6 (VDD), U1-0.7 (REGIN), U2-0.5 (OUT), U5-0.8 (VCC), U6-0.1 (RESV), U6-0.8 (VDDIO), U6-0.9 (AD0/SDO), U6-0.13 (VDD), U6-0.22 (NCS), U7-0.2 (CSB), U7-0.6 (VDDIO), U7-0.8 (VDD)
5V: D2_1-0.A, J2-T-0.34, J2-T-0.36, J4-B-0.2, J4-B-0.4, LED4_1-0.A, Q5-0.1 (G), R2_1-0.2, U1-0.8 (VBUS), U4-0.4 (VIN), USB1.1 (VBUS)
/ADC: J2-T-0.35, J4-B-0.1, R5_1-0.1, R5_2-0.2, U5-0.2 (ADC)
/ADC_IN: R5_1-0.2, U$9.1
/BATT: J2-T-0.32, J4-B-0.6, PWR1-0.+, TP2.P$1, U$7.2, U$9.2
/CH_PD: J2-T-0.3, J4-B-0.33, R5_8-0.1, U5-0.3 (CH_PD)
/D+: U1-0.3 (D+), USB1.3 (D+)
/D-: U1-0.4 (D-), USB1.2 (D-)
/DTR: Q1-0.2 (E), R5_5-0.2, U1-0.23 (DTR)
/EN: R2_2-0.1, U2-0.3 (EN), U3-0.9 (EN)
/GPIO0: J2-T-0.17, J2-T-0.24, J4-B-0.14, J4-B-0.19, Q1-0.3 (C), U5-0.12 (GPIO0)
/GPIO2: J2-T-0.15, J4-B-0.21, R5_7-0.1, U5-0.11 (GPIO2)
/GPIO12: J2-T-0.9, J2-T-0.14, J4-B-0.24, J4-B-0.27, JP1.3, U5-0.6 (GPIO12)
/GPIO13: J2-T-0.7, J2-T-0.16, J4-B-0.22, J4-B-0.29, U5-0.7 (GPIO13), U$11.2
/GPIO14: J2-T-0.5, J2-T-0.18, J4-B-0.20, J4-B-0.31, U5-0.5 (GPIO14), U$12.1
/GPIO15: J2-T-0.11, J4-B-0.25, R5_9-0.2, U5-0.10 (GPIO15), U$13.2
/GPIO16: J2-T-0.13, J4-B-0.23, U5-0.4 (GPIO16), U$4.2
/INT_MPU: U6-0.12 (INT), U$12.2
/NEOPIXEL_IN: R8_1-0.1, U$13.1
/PS_HOLD: JP1.2, U3-0.4 (PS_HOLD)
/RESET: J2-T-0.26, J4-B-0.12, Q2-0.2 (E), R5_6-0.2, U5-0.1 (RESET), U$4.1
/RTS: Q2-0.3 (C), R5_4-0.2, U1-0.19 (RTS)
/RXD: J2-T-0.22, J4-B-0.16, R5_3-0.2, U5-0.15 (RXD)
/SCL: J2-T-0.10, J2-T-0.21, J4-B-0.15, J4-B-0.28, R6_1-0.1, U5-0.14 (GPIO5), U6-0.23 (SCL/SCLK), U7-0.4 (SCK)
/SDA: J2-T-0.12, J2-T-0.19, J4-B-0.17, J4-B-0.26, R6_2-0.1, U5-0.13 (GPIO4), U6-0.24 (SDA/SDI), U7-0.3 (SDI)
/TXD: J2-T-0.20, J4-B-0.18, U1-0.20 (RXD), U5-0.16 (TXD)
/USB_RX: R5_3-0.1, U1-0.21 (TXD)
/VBATT: C4_1-0.2, J2-T-0.30, J4-B-0.8, Q5-0.3 (D), U4-0.3 (VBAT), U$7.1
/VIN: C2_1-0.1, D2_1-0.C, Q5-0.2 (S), R2_2-0.2, U2-0.1 (IN), U3-0.1 (VCC)
/~INT~: R3_2-0.1, U3-0.11 (~INT~)
/~PB~: J2-T-0.28, J4-B-0.10, S2.2, U3-0.2 (~SR~), U3-0.6 (~PB~)
/~PB~_OUT: R3_3-0.1, U3-0.8 (~PB~_OUT), U$11.1
GND: C1_1-0.2, C1_2-0.2, C2_1-0.2, C2_2-0.2, C2_3-0.2, C3_1-0.2, C3_2-0.2, C4_1-0.1, C6_1-0.2, C6_2-0.1, C6_3-0.2, C7_1-0.2, C8_1-0.2, J2-T-0.2, J2-T-0.4, J4-B-0.34, J4-B-0.36, LED1-0.4 (GND), PWR1-0.-, R2_1-0.1, R4-1-0.2, R5_2-0.1, R5_9-0.1, S2.3, TP1.P$1, U1-0.2 (GND), U1-0.THERM (TP), U2-0.2 (GND), U3-0.12 (GND), U4-0.2 (VSS), U5-0.9 (GND), U6-0.11 (FSYNC), U6-0.18 (GND), U6-0.20 (RESV@2), U7-0.1 (GND), U7-0.5 (SDO), U7-0.7 (GND), USB1.5 (GND), USB1.P1 (SHIELD), USB1.P2 (SHIELD), USB1.P5 (SHIELD), USB1.P6 (SHIELD), USB1.P$3 (SHIELD), USB1.P$4 (SHIELD)
unnamed: C1_1-0.1, U1-0.16 (VPP)
unnamed: C3_1-0.1, U3-0.5 (CSRD)
unnamed: C3_2-0.1, U3-0.3 (VREF)
unnamed: C6_2-0.2, U6-0.10 (REGOUT)
unnamed: LED1-0.1 (DI), R8_1-0.2
unnamed: LED4_1-0.C, R4_2-0.1
unnamed: Q1-0.1 (B), R5_4-0.1
unnamed: Q2-0.1 (B), R5_5-0.1
unnamed: R3_10.1, U3-0.10 (~RST~)
unnamed: R4-1-0.1, U4-0.5 (PROG)
unnamed: R4_2-0.2, U4-0.1 (STAT)

Notes on the sheet:
10K = 100mA
5.0K = 200mA
2.0K = 500mA
1.0K = 1000mA
LIPO CHARGING
POWER AND FILTERING
USB TO SERIAL CONVERTER
TOP
LIPO VOLTAGE MEASURMENT
I2C PULL-UP
GPIO0 : Output used for boot
CSRD= 1uF /10s of push to stop
Button
MPU_INT
INT_MPU
FOr USB device id customization
PB_OUT
PS_HOLD
GPIO2 : Output used for boot
GPIO15 : Output used for boot
GPIO16 : Used for deep sleep
DEEPSLEEP
NEOPIXEL
BOTTOM
ESP12
Fiducials
Top
Bottom
Put jumper to send GPIO0 and 2 on the connector ?
FOR DEBUG
Should Be 4.7uF
ADR pin
2V-20ma-red
DMG3415U

Board: 4 copper layers, 33.0 x 33.0 mm, 81 parts (0 on the bottom side), 44 nets.

Other parts of the board:
@HOLE0, @HOLE1, @HOLE2, @HOLE3, @HOLE4, @HOLE5, @HOLE6, @HOLE7, @HOLE8, @HOLE9, @HOLE10, @HOLE11, @HOLE12, @HOLE13, @HOLE14, @HOLE15, @HOLE16, @HOLE17, @HOLE18, @HOLE19: (no value)

## Commit log

2021-03-05 organize
2021-03-05 FirmWare normaly OK
2021-03-05 unity sensitive pen project
2021-03-05 update
    firmware
    Unity project
2021-03-12 update unity read serial
    Add acceleration mag et gyr en lecture hexa
2021-04-23 uodate
2021-04-29 update visu stylo
2021-05-04 doc python
2021-06-01 update before fork
2021-06-01 unity organisation
2021-06-01 update unity
2021-07-22 init base test NF5316
2021-07-23 udpdate
2021-07-28 Add Features extraction Files
2021-07-28 Data management
2021-07-28 pudate
2021-07-28 add coubre
2021-07-29 update visualize complete file
2021-07-29 update firmware muca
2021-07-29 upda
2021-07-29 irgi
2021-08-12 add interface script
2021-08-19 Add requirements
2021-09-16 init doc re orga
2021-09-16 init doc
2021-09-23 init pcb
2021-09-29 Extract in other folder ok
2021-09-29 last commit before big change
2021-09-29 up 4 the day
2021-10-02 update reorgz code
2021-10-05 adding paul taffe
2021-10-05 adding paul stuff
2021-10-07 Pressure Shield v1.0
2021-10-07 updte reu adrien paul
2021-10-07 rename
2021-10-08 init connector
2021-10-11 ajout_data
2021-10-11 update code
2021-10-21 Update Firmware_movuino_esp8266_stylo_NoWifi.ino
    time out is in sec from movuino
2021-10-21 ajout_data_personnesâgées
2021-10-29 ajout_data2
2021-11-04 init ok
2021-11-08 update (?)
2021-11-08 init firmware c++
2021-11-08 base
2021-11-09 clean record
2021-11-09 clean read files + init button behavior
2021-11-09 init neopixel
2021-11-10 neopixel ok
2021-11-10 fix blink
2021-11-10 init lerp behavior (ok)
2021-11-10 update regression lin
2021-11-15 v1.0.1
2021-11-24 design rule ok
2021-11-25 update path
2021-12-06 Add_data_garches
2021-12-06 updta
2021-12-07 update modif code radpide
2021-12-07 updtae gui
2021-12-09 Data_garches_0812
2021-12-11 angle_method extraction changelent
2021-12-13 add shield
2021-12-14 update for jlcpcb
2022-01-14 Add_Data_Children
2022-01-15 updtae
2022-01-19 Extraction of raw data window for further feature engineering
    In order to further develop the features, I made the data window accessible and created a file called "createFeatues" that receives the raw data window as input. (see dummy feature "avgAccX")
2022-02-03 created matrix converting raw data to: [time, accX_tip, ... ,accX_Top,...,theta,psi]
2022-02-03 edit window creation
2022-02-23 feature specific files implemented
2022-02-23 add feature files
2022-02-23 Ceate Allo
2022-02-23 edited featureCreation
2022-02-23 Add test_data folder with one df
2022-02-23 add tilt features
2022-02-23 added testing files
2022-02-28 model incorporated
2022-03-01 model prototype finalized
2022-03-02 Added kinematic features
    Included in the new model - adapted createFeatures.py
2022-03-02 Integrated min max of window
2022-03-22 prep for Ana
2022-03-26 children prediction
2022-03-28 Change of paths in the main_Ana.py file, relative paths makes it functional for everyone
2022-03-28 Compute Feature Correlation
2022-03-29 Feature to Feature and Feature to Label Correlation Plots
2022-04-06 Small changes to feature importance
2022-04-06 added age and gender to features
2022-04-06 Revert "Merge branch 'main' of https://github.com/felixbastian/SensitivePen"
    This reverts commit 939fceb137a54811370eb4cdaa6e3334ef7b3efd, reversing
    changes made to fd026a1d37a2e315fde5a55f2c5c7d301c4be94a.
2022-04-06 Add feature selection pipeline
2022-04-11 Age changed to timestamp - adjust feature selection
    Feature selection will now only delete numerical features
2022-04-20 include label for model (started)
2022-04-20 ML begin-end
2022-04-25 changed window-wise to subject-wise evaluation
2022-04-27 classification
2022-05-11 add_classification
2022-05-11 classification_update
2022-05-17 minor
2022-05-20 minor changes
2022-05-23 ANOVA test
2022-05-25 Update tiltFeatures.py
    added new features for comparison with assel born 2018 interpretation
